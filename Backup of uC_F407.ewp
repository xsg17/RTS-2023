# IAR project Backup of uC_F407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: APP; APP\Cfg; APP\Inc; BSP\Inc; Driver\CMSIS\Device\Inc; Driver\CMSIS\Include; Driver\STM32F4xx_Std_Lib\Inc; uCOS\uC-CPU\ARM-Cortex-M4; uCOS\uC-CPU; uCOS\uC-LIB; uCOS\uCOS-III\Ports; uCOS\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uC_F407.srec
  ILINK.IlinkOutputFile: uC_F407.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    APP/: app.c includes.h
    APP/Src/: os_app_hooks.c
  group App/Cfg
    APP/Cfg/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
  group BSP
    BSP/Src/: action.c beep.c bsp.c BT.c can.c DataProcessing.c led.c PID.c robomodule.c RobotCtrl.c stm32f4xx_it.c tim.c usart.c
  group ST/Compiled
    Driver/STM32F4xx_Std_Lib/Src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group ST/Uncompiled
    Driver/STM32F4xx_Std_Lib/Src/: stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_wwdg.c
  group System
    Driver/CMSIS/Device/Src/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group uC/CPU
    uCOS/uC-CPU/ARM-Cortex-M4/: cpu.h cpu_a.asm cpu_c.c
    uCOS/uC-CPU/: cpu_core.c cpu_def.h
  group uC/LIB
    uCOS/uC-LIB/: lib_ascii.c lib_def.h lib_math.c lib_mem.c lib_str.c
    uCOS/uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS-3/Ports
    uCOS/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-3/Source
    uCOS/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
